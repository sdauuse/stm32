# Keil uVision project main.uvproj, settings and files
target 智能晾衣架 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE\MATRIX BUTTONS;..\HARDWARE\OLED;..\HARDWARE\PHOTORESISTANCE;..\HARDWARE\PWM;..\HARDWARE\TEMPERATURE AND HUMIDITY SENSOR;..\OBJ;..\SYSTEM\DELAY;..\SYSTEM\STC15W4K32S4;..\SYSTEM\SYS;..\USER;..\OBJ;..\HARDWARE\RAIN
  group USER
    ./: main.c 日志
  group HARDWARE
    ../HARDWARE/MATRIX BUTTONS/: matrix buttons.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/TEMPERATURE AND HUMIDITY SENSOR/: TAHS.c
    ../HARDWARE/PWM/: PWM.c
    ../HARDWARE/RAIN/: rain.c
  group SYSTEM
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/DELAY/: delay.c
  group OBJ
    ../OBJ/: RUN.c
